PROGRAM MAIN
VAR
	PlcVar AT %Q* :  DINT := 12; 
END_VAR

END_PROGRAM
